## DOC
# https://docs.mender.io/system-updates-yocto-project/customize-mender

#SYSTEMD_AUTO_ENABLE = "disable"
